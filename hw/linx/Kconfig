## hw/linx/Kconfig
```kconfig
config LINX_VIRT
    bool
    default y
    depends on LINX
    select DEVICE_TREE
    select SERIAL
    select VIRTIO_MMIO
```
